# Keil uVision project Water_Level_Monitoring_&_Pump_Controller.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Water_Level_Monitoring +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Water_Level_Monitoring_&_Pump_Controller.c
